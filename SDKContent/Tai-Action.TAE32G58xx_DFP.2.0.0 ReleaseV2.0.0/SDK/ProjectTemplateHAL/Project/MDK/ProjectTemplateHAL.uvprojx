# Keil uVision project ProjectTemplateHAL.uvprojx, settings and files
target FLASH (6140001::V6.14.1::ARMCLANG)
  device: TAE32G580x Tai-Action
  pack: Tai-Action.TAE32G580x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectTemplateHAL +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\LL;..\..\..\Drivers\TAE32G58xx_Driver\HAL;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\FLASH\tae32g58xx_ac6_flash.sct
  group ProjectTemplateHAL/User
    ../../User/Src/: main.c tae32g58xx_hal_board.c tae32g58xx_hal_msp.c tae32g58xx_it.c
  group Documentation
    ../../: readme.md
  group Drivers/CMSISv6
    ../../../Drivers/CMSISv6/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm52.h core_cm55.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h core_starmc3.h tz_context.h
  group Drivers/TAE_Driver/HAL
    ../../../Drivers/TAE32G58xx_Driver/HAL/: tae32g58xx_hal.c tae32g58xx_hal_adc.c tae32g58xx_hal_adtmr.c tae32g58xx_hal_bstmr.c tae32g58xx_hal_can.c tae32g58xx_hal_cmp.c tae32g58xx_hal_cortex.c tae32g58xx_hal_dac.c tae32g58xx_hal_dma.c tae32g58xx_hal_eflash.c tae32g58xx_hal_gpio.c tae32g58xx_hal_gptmrx.c tae32g58xx_hal_gptmry.c tae32g58xx_hal_hrpwm.c tae32g58xx_hal_i2c.c tae32g58xx_hal_iir.c tae32g58xx_hal_iwdg.c tae32g58xx_hal_lptmr.c tae32g58xx_hal_qei.c tae32g58xx_hal_rcu.c tae32g58xx_hal_spi.c tae32g58xx_hal_sysctrl.c tae32g58xx_hal_uart.c tae32g58xx_hal_wwdg.c
  group Drivers/TAE_Driver/LL
    ../../../Drivers/TAE32G58xx_Driver/LL/: tae32g58xx_ll.h tae32g58xx_ll_adc.h tae32g58xx_ll_adtmr.h tae32g58xx_ll_bstmr.h tae32g58xx_ll_can.h tae32g58xx_ll_cmp.h tae32g58xx_ll_cortex.h tae32g58xx_ll_dac.h tae32g58xx_ll_def.h tae32g58xx_ll_dma.h tae32g58xx_ll_eflash.h tae32g58xx_ll_gpio.h tae32g58xx_ll_gptmrx.h tae32g58xx_ll_gptmry.h tae32g58xx_ll_hrpwm.h tae32g58xx_ll_i2c.h tae32g58xx_ll_iir.h tae32g58xx_ll_iwdg.h tae32g58xx_ll_lptmr.h tae32g58xx_ll_qei.h tae32g58xx_ll_rcu.h tae32g58xx_ll_spi.h tae32g58xx_ll_sysctrl.h tae32g58xx_ll_uart.h tae32g58xx_ll_wwdg.h
  group Drivers/TAE_Device
    ../../../Drivers/TAE32G58xx_Device/Src/: startup_tae32g58xx.c system_tae32g58xx.c
  group Utilities/Debug
    ../../../Utilities/dbg/: user_debug.c
target SRAM (6140001::V6.14.1::ARMCLANG)
  device: TAE32G580x Tai-Action
  pack: Tai-Action.TAE32G580x_DFP.2.0.0
  cpu: as above
  output: ProjectTemplateHAL +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\CMSISv6\Core\Include;..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\HAL;..\..\..\Drivers\TAE32G58xx_Driver\LL;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\SRAM\tae32g58xx_ac6_sram.sct
software components: CMSIS:CORE 5.6.0
