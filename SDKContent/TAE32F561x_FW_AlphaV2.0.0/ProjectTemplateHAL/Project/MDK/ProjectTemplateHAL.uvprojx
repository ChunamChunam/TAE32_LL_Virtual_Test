# Keil uVision project ProjectTemplateHAL.uvprojx, settings and files
target FLASH (6140001::V6.14.1::ARMCLANG)
  device: TAE32F5610 Tai-Action
  pack: Tai-Action.TAE32F561x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x20004000,0x4000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectTemplateHAL +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32F561x_Device\Inc;..\..\..\Drivers\TAE32F561x_Driver\LL;..\..\..\Drivers\TAE32F561x_Driver\HAL;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: .\FLASH\tae32f561x_ac6_flash.sct
  group ProjectTemplateHAL/User
    ../../User/Src/: main.c tae32f561x_hal_board.c tae32f561x_hal_msp.c tae32f561x_it.c
  group Documentation
    ../../: readme.md
  group Drivers/CMSISv6
    ../../../Drivers/CMSISv6/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm52.h core_cm55.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h core_starmc3.h tz_context.h
  group Drivers/TAE_Driver/HAL
    ../../../Drivers/TAE32F561x_Driver/HAL/: tae32f561x_hal.c tae32f561x_hal_bstmr.c tae32f561x_hal_cortex.c tae32f561x_hal_dma.c tae32f561x_hal_eflash.c tae32f561x_hal_gpio.c tae32f561x_hal_iwdg.c tae32f561x_hal_wwdg.c tae32f561x_hal_sysctrl.c tae32f561x_hal_rcu.c
  group Drivers/TAE_Driver/LL
    ../../../Drivers/TAE32F561x_Driver/LL/: tae32f561x_ll.h tae32f561x_ll_bstmr.h tae32f561x_ll_cortex.h tae32f561x_ll_def.h tae32f561x_ll_dma.h tae32f561x_ll_eflash.h tae32f561x_ll_gpio.h tae32f561x_ll_iwdg.h tae32f561x_ll_rcu.h tae32f561x_ll_sysctrl.h tae32f561x_ll_uart.h tae32f561x_ll_wwdg.h
  group Drivers/TAE_Device
    ../../../Drivers/TAE32F561x_Device/Src/: startup_tae32f561x.c system_tae32f561x.c
  group Utilities/Debug
    ../../../Utilities/dbg/: user_debug.c
target SRAM (6140001::V6.14.1::ARMCLANG)
  device: TAE32F5610 Tai-Action
  pack: Tai-Action.TAE32F561x_DFP.1.0.1
  cpu: as above
  output: ProjectTemplateHAL +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32F561x_Device\Inc;..\..\..\Drivers\TAE32F561x_Driver\HAL;..\..\..\Drivers\TAE32F561x_Driver\LL;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: .\SRAM\tae32f561x_ac6_sram.sct
software components: CMSIS:CORE 5.6.0
